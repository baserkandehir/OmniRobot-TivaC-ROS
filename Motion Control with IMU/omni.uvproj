# Keil uVision project omni.uvproj, settings and files
target Target (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: omni
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group
    ./: main.c startup.s PLL.c PortF.c SysTick.c PWM.c MotorControl.c UART.c Timers.c EdgeInterrupts.c PID.c Encoders.c OmniControl.c Behaviors.c
